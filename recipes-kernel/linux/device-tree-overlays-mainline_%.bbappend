FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-DTS-for-TIS-sensors.patch;patchdir=.."

